<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Wired_mouse_prototype.ewp</path>
  </project>
  <batchBuild />
</workspace>
